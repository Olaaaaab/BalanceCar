# Keil uVision project main.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: XLZN +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_ HD,USE_STDPERIPH_DRIVER
  c misc: --C99
  c include: ..\System\delay;..\System\sys;..\System\usart;..\User;..\Hardware\ADC;..\Hardware\DMP;..\Hardware\ENCODER;..\Hardware\EXTI;..\Hardware\IIC;..\Hardware\LED;..\Hardware\KEY;..\Hardware\MOTOR;..\Hardware\MPU6050;..\Hardware\OLED;..\STM32F10x_FWLib\src;..\STM32F10x_FWLib\inc;..\Coer;..\Hardware\Track;..\Hardware\Ultra
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group Hardware
    ../Hardware/ADC/: adc.c
    ../Hardware/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../Hardware/ENCODER/: encoder.c
    ../Hardware/EXTI/: exti.c
    ../Hardware/IIC/: IOI2C.c
    ../Hardware/KEY/: key.c
    ../Hardware/LED/: LED.C
    ../Hardware/MOTOR/: motor.c
    ../Hardware/MPU6050/: MPU6050.c
    ../Hardware/OLED/: oled.c
    ../Hardware/Track/: Track.C
    ../Hardware/Ultra/: Ultra.C
  group Coer
    ../Coer/: core_cm3.c startup_stm32f10x_hd.s
  group STM32F10x_FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group System
    ../System/delay/: delay.c
    ../System/sys/: sys.c
    ../System/usart/: usart.c
software components: CMSIS:CORE 5.4.0
